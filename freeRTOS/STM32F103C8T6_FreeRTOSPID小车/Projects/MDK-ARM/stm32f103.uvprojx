# Keil uVision project stm32f103.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Users;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\uart1;..\..\Drivers\SYSTEM\sys;..\..\Drivers\BSP\key;..\..\Drivers\BSP\led;..\..\Drivers\BSP\OLED;..\..\freeRTOS\include;..\..\freeRTOS\portable;..\..\freeRTOS;..\..\freeRTOS;..\..\freeRTOS;..\..\Drivers\BSP\TIME;..\..\Drivers\BSP\encode;..\..\Drivers\BSP\Motor;..\..\Drivers\BSP\RT;..\..\Drivers\BSP\led;..\..\Drivers\BSP\PID;..\..\Drivers\BSP\bluetoos;..\..\Drivers\BSP\MPU6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f101xb.s
  group User
    ../../Users/: main.c stm32f1xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/BSP
    ../../Drivers/BSP/OLED/: OLED.c OLED_Data.c
    ../../Drivers/BSP/key/: key.c
    ../../Drivers/BSP/led/: led.c
    ../../Drivers/BSP/TIME/: timer.c
    ../../Drivers/BSP/encode/: Encoder.c
    ../../Drivers/BSP/Motor/: Motor.c PWM.c
    ../../Drivers/BSP/PID/: PID.c
    ../../Drivers/BSP/bluetoos/: bluetoos.c
    ../../Drivers/BSP/MPU6050/: MPU6050.c MyI2C.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/uart1/: uart1.c
    ../../Drivers/SYSTEM/sys/: sys.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group freeRTOS/include
    ../../freeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freeRTOS/portable
    ../../freeRTOS/portable/: heap_4.c port.c portmacro.h
  group freeRTOS
    ../../freeRTOS/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c stream_buffer.c tasks.c timers.c FreeRTOS_demo.c
