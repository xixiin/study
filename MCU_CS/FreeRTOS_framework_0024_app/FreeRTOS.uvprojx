# Keil uVision project FreeRTOS.uvprojx, settings and files
target SWM320 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.8.4
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: FreeRTOS +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: .\build_ota_file.bat
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\SWM320_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM320_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM320_StdPeriph_Driver\CSL\SWM320_StdPeriph_Driver;.\APP;.\APP\FreeRTOS\include;.\APP\FreeRTOS\portable\RVDS\ARM_CM3;.\APP\task;.\framework\driver;.\framework;.\framework\driver_port;.\framework\lib_loopbuf;.\framework\lib_utc;.\framework\lib_FAL\fal\src;.\framework\lib_FAL\fal_port;.\APP\work;.\framework\lib_FAL\fal\inc;.\APP\network\air7xx;.\APP\network;.\APP\comdline;.\framework\lib_stropt;.\framework\lib_HC595;.\APP\led_board;.\APP\hlw8012;.\APP\message
  library: MicroLIB
  memory RVCT4: ROM 0x11800 size 0x2e800
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ./app/: main.c
  group FreeRTOS
    ./APP/FreeRTOS/: list.c queue.c tasks.c timers.c croutine.c
  group FreeRTOS\port
    ./APP/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./APP/FreeRTOS/portable/MemMang/: heap_4.c
  group CSL\StdPD
    ../../SWM320_StdPeriph_Driver/CSL/SWM320_StdPeriph_Driver/: SWM320_adc.c SWM320_exti.c SWM320_gpio.c SWM320_i2c.c SWM320_pwm.c SWM320_timr.c SWM320_uart.c SWM320_wdt.c SWM320_dma.c SWM320_flash.c SWM320_port.c SWM320_spi.c SWM320_can.c SWM320_crc.c SWM320_lcd.c SWM320_rtc.c SWM320_sdio.c
  group CSL\CMSIS
    ../../SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM320.c
    ../../SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM320.s
  group app/task
    ./APP/task/: task_ctrl.c task_host.c task_lisen.c task_start.c
  group fk/driver
    ./framework/driver/: fk_drv_gpio.c fk_drv_uart.c fk_drv_rtc.c fk_drv_wdt.c
  group fk/driver_port
    ./framework/driver_port/: fk_drvp_gpio.c fk_drvp_uart.c fk_drvp_rtc.c fk_drvp_wdt.c
  group lib_loopbuf
    ./framework/lib_loopbuf/: loopbuf.c
  group lib_utc
    ./framework/lib_utc/: utc.c
  group fk/lib_fal/fal
    ./framework/lib_FAL/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group fk/lib_fal/fal_port
    ./framework/lib_FAL/fal_port/: fal_flash_swm320.c fal_cfg.h
  group app/work
    ./APP/work/: work.c work_data.c work.h work_fuse.c work_sock_ctrl.c work_deal_order.c work_cycle_reboot.c work_debug.c
  group network
    ./APP/network/: network.c network.h
  group network/air7xx
    ./APP/network/air7xx/: air7xx.c air7xx.h air7xx_base_opt.c air7xx_work_connect_serv.c air7xx_work_init_dev.c air7xx_work_rst_dev.c
  group comdline
    ./APP/comdline/: comdline.c comdline.h
  group lib_stropt
    ./framework/lib_stropt/: stropt.c stropt.h
  group lib_HC595
    ./framework/lib_HC595/: HC595.c HC595.h
  group led_board
    ./APP/led_board/: led_board.c led_board.h
  group app/hlw8012
    ./APP/hlw8012/: hlw8012.c hlw8012.h
  group app/message
    ./APP/message/: message.h message.c msg_cmd_analysis.c msg_ctrl_to_net.c meg_net_to_ctrl.c
