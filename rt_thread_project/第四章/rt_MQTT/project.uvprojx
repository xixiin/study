# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: GD32F30X_HD, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, __STDC_LIMIT_MACROS, RT_USING_LIBC, __RTTHREAD__
  c include: rt-thread\components\dfs\dfs_v1\include;rt-thread\components\net\sal\include\socket;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\net\sal\include;packages\at_device-latest\inc;rt-thread\components\drivers\include;rt-thread\libcpu\arm\common;packages\at_device-latest\class\esp8266;rt-thread\components\drivers\include;rt-thread\components\drivers\include;libraries\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;rt-thread\components\net\sal\impl;rt-thread\components\drivers\phy;rt-thread\components\net\at\include;.;rt-thread\components\libc\posix\io\epoll;rt-thread\components\libc\posix\io\poll;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\include;board;libraries\gd32_drivers;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\libc\posix\ipc;rt-thread\components\net\at\at_socket;rt-thread\components\net\sal\include\socket\sys_socket;applications;libraries\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;rt-thread\components\libc\compilers\common\extension;packages\kawaii-mqtt-latest\mqttclient;rt-thread\components\drivers\include;packages\kawaii-mqtt-latest\platform\RT-Thread;libraries\GD32F30x_Firmware_Library\CMSIS;packages\kawaii-mqtt-latest\common;rt-thread\components\finsh;rt-thread\components\net\netdev\include;rt-thread\components\drivers\smp_call;rt-thread\include;packages\cJSON-v1.7.17;rt-thread\components\dfs\dfs_v1\filesystems\devfs;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\kawaii-mqtt-latest\network;packages\kawaii-mqtt-latest\mqtt;packages\kawaii-mqtt-latest\common\log;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Applications
    applications/: main.c
  group AT
    rt-thread/components/net/at/src/: at_cli.c at_utils.c at_client.c
    rt-thread/components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/src/: at_device.c
    packages/at_device-latest/samples/: at_sample_esp8266.c
    packages/at_device-latest/class/esp8266/: at_socket_esp8266.c at_device_esp8266.c
  group cJSON
    packages/cJSON-v1.7.17/: cJSON_Utils.c cJSON.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/can/: dev_can.c
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
    rt-thread/components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/: board.c
    libraries/GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
    libraries/gd32_drivers/: drv_adc.c drv_can.c drv_gpio.c drv_spi.c drv_usart.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: cmd.c shell.c msh_parse.c msh.c msh_file.c
  group kawaii_mqtt
    packages/kawaii-mqtt-latest/mqttclient/: mqttclient.c
    packages/kawaii-mqtt-latest/mqtt/: MQTTSubscribeServer.c MQTTConnectClient.c MQTTFormat.c MQTTUnsubscribeClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTUnsubscribeServer.c MQTTSubscribeClient.c MQTTConnectServer.c MQTTSerializePublish.c
    packages/kawaii-mqtt-latest/platform/RT-Thread/: platform_net_socket.c platform_mutex.c platform_timer.c platform_memory.c platform_thread.c
    packages/kawaii-mqtt-latest/common/log/: format.c salof.c fifo.c
    packages/kawaii-mqtt-latest/network/: nettype_tls.c network.c nettype_tcp.c
    packages/kawaii-mqtt-latest/common/: random.c mqtt_list.c
    packages/kawaii-mqtt-latest/common/log/arch/rt-thread/: arch.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    rt-thread/src/klibc/: kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c kerrno.c
  group libcpu
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    libraries/GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_usart.c gd32f30x_rcu.c gd32f30x_spi.c gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_adc.c gd32f30x_misc.c gd32f30x_can.c
    libraries/GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_at.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
software components: CMSIS:CORE 5.4.0
