# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: __STDC_LIMIT_MACROS, RT_USING_LIBC, GD32F30X_HD, USE_STDPERIPH_DRIVER, __RTTHREAD__, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: rt-thread\components\finsh;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\dfs\dfs_v1\filesystems\devfs;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\include;libraries\GD32F30x_Firmware_Library\CMSIS;rt-thread\components\libc\posix\io\epoll;rt-thread\components\dfs\dfs_v1\include;libraries\gd32_drivers;board;.;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;libraries\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\smp_call;rt-thread\libcpu\arm\common;rt-thread\include;libraries\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\posix\io\poll;applications;rt-thread\components\drivers\phy;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
    rt-thread/components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/: board.c
    libraries/GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
    libraries/gd32_drivers/: drv_gpio.c drv_spi.c drv_usart.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: cmd.c shell.c msh_parse.c msh_file.c msh.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    rt-thread/src/klibc/: kstdio.c rt_vsnprintf_tiny.c rt_vsscanf.c kstring.c kerrno.c
  group libcpu
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    libraries/GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_misc.c gd32f30x_exti.c gd32f30x_usart.c gd32f30x_gpio.c gd32f30x_spi.c gd32f30x_rcu.c
    libraries/GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
software components: CMSIS:CORE 5.4.0
