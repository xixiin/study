# Keil uVision project stm32f103.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Users;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\uart1;..\..\Drivers\SYSTEM\sys;..\..\Drivers\BSP\key;..\..\Drivers\BSP\OLED;..\..\Drivers\BSP\led;..\..\Drivers\BSP\TIME;..\..\Drivers\BSP\RT;..\..\Drivers\BSP\Motor;..\..\Drivers\BSP\encode;..\..\Drivers\BSP\bluetoos;..\..\Drivers\BSP\PID;..\..\Drivers\BSP\MPU6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group User
    ../../Users/: main.c stm32f1xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/BSP
    ../../Drivers/BSP/OLED/: OLED.c OLED_Data.c
    ../../Drivers/BSP/key/: key.c
    ../../Drivers/BSP/led/: led.c
    ../../Drivers/BSP/TIME/: timer.c
    ../../Drivers/BSP/Motor/: Motor.c PWM.c
    ../../Drivers/BSP/encode/: Encoder.c
    ../../Drivers/BSP/PID/: PID.c
    ../../Drivers/BSP/MPU6050/: MPU6050.c MyI2C.c
    ../../Drivers/BSP/bluetoos/: BlueSerial.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/uart1/: uart1.c
    ../../Drivers/SYSTEM/sys/: sys.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
